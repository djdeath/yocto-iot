require iot-devkit-image.bb

DESCRIPTION = "A fully functional image to be placed on an SD card with full profiling"

IMAGE_INSTALL += "packagegroup-core-tools-profile"

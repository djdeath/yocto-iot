DESCRIPTION = "LCD library that communicates with a HD44780 LCD (saintsmart LCD2004) on i2c"
HOMEPAGE = "http://developer.intel.com/"
SECTION = "utils"

LICENSE = "MIT & GPLv2 & LGPLv2.1"
LIC_FILES_CHKSUM = "file://COPYING;md5=e8db6501ed294e65418a933925d12058"

SRC_URI = "file://hd44780lib-0.1.0.tar.bz2"

inherit autotools

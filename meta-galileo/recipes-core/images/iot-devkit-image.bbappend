IMAGE_INSTALL += "mtd-utils-jffs2"
